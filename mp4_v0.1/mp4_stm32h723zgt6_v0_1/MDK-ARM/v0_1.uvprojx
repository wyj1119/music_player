# Keil uVision project v0_1.uvprojx, settings and files
target v0_1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: v0_1 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,STM32H7
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../MDK-ARM;./FreeRTOS/include;./FreeRTOS/portable/RVDS/ARM_CM7/r0p1;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;./LVGL/GUI;./LVGL/GUI/lvgl;./LVGL/GUI/lvgl/src;./LVGL/GUI/lvgl/examples/porting;.\LVGL\GUI_APP\demos;.\LVGL\GUI_APP\demos\stress;.\LVGL\GUI_APP\demos\music
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c dma2d.c fmc.c i2c.c usart.c ltdc.c octospi.c rng.c sai.c sdmmc.c tim.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group HARDWARE
    ./: norflash.c sdram.c key.c rgb_lcd.c gt911.c
  group SOFTWARE
    ./: wav_play.c lvgl_task.c kai_24.c
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_PORT
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group lvgl/example/porting
    ./LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group lvgl/src/core
    ./LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./LVGL/GUI/lvgl/: lv_conf.h
  group lvgl/src/draw
    ./LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ./LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/extra
    ./LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ./LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ./LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ./LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ./LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ./LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group lvgl/src/font
    ./LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/gpu
    ./LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group lvgl/src/hal
    ./LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ./LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ./LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group icon
    ./icon/: pause.c play.c next.c previous.c shuffle.c repeatOne.c repeat.c
software components: CMSIS:CORE 4.3.0
